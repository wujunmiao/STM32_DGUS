# Keil uVision project lcd_test.uvproj, settings and files
target lcd_test (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: lcd_test
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\utilities\include;..\..\test;..\..\..\filesys\ff\src;..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../: test_lcd.c stm32f4xx_it.c
  group utilities
    ../../../utilities/usart/: uart1.c uart2.c uart3.c uart4.c uart5.c uart6.c
    ../../../utilities/sd/: MMC_SD.C sd.c
    ../../../utilities/spi_flash/: spi_flash.c
    ../../../utilities/serialscreen/: serialscreen.c
    ../../../utilities/szt_Gpboc/: szt_gpboc.c
    ../../../utilities/bill/: bill.c
    ../../../utilities/protocol/: protocol.c
    ../../../utilities/rtc/: rtc.c
    ../../../utilities/delay/: delay.c
    ../../../utilities/coins/: coin.c
    ../../../utilities/mini_hopper/: Mini_hopper.c
    ../../../utilities/LedMsgHandle/: MsgHandle.c
    ../../../utilities/network_handle/: network_handle.c
    ../../../utilities/printer/: printer.c
    ../../../utilities/bsp/: bsp.c
    ../../../utilities/vioce/: voice.c
    ../../../utilities/tim_pwm/: timer2.c timer3.c timer4.c timer6.c
    ../../../utilities/PVD/: pvd.c
    ../../../utilities/eeprom/: eeprom.c
    ../../../utilities/intel_flash/: intel_flash.c
  group fatfs
    ../../../filesys/ff/src/: diskio.c ff.c
    ../../../filesys/ff/src/option/: ccsbcs.c
  group StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_tim.c stm32f4xx_sdio.c stm32f4xx_rng.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_spi.c stm32f4xx_pwr.c stm32f4xx_iwdg.c
  group MDK-ARM
    ../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group CMSIS
    ../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group include
    ../../../utilities/include/: uart1.h uart2.h uart3.h uart4.h uart5.h uart6.h bill.h bsp.h coin.h delay.h Mini_hopper.h MMC_SD.H MsgHandle.h network_handle.h printer.h rtc.h sd.h serialscreen.h spi_flash.h protocol.h szt_gpboc.h vioce.h timer2.h timer3.h timer4.h timer6.h PVD.h eeprom.h intel_flash.h
